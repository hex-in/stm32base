# Keil uVision project abox.uvprojx, settings and files
target app (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: abox
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ..\include;..\..\..\include;..\..\..\platforms\include;..\..\..\libraries\utilities\ring_buffer;..\..\..\platforms\STM32F4xx;..\..\..\platforms\ARM_CM4\CMSIS;..\..\..\platforms\STM32F4xx\peripherals;..\..\..\platforms\STM32F4xx\peripherals\libraries;..\..\..\system\FreeRTOS\ver10.0.1\Source\include;..\..\..\platforms\STM32F4xx\peripherals\libraries\inc;..\..\..\system\FreeRTOS\ver10.0.1\Source\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\scatter\abox.sct
  group apps\abox\source
    ../source/: main.c
  group apps\abox\startup
    ../startup/: startup_stm32f405xx.s
  group system\FreeRTOS
    ../../../system/FreeRTOS/: hexin_freertos.c
  group system\ARM_CM4
    ../../../system/ARM_CM4/: low_level_init.c
  group libraries\utilities\ring_buffer
    ../../../libraries/utilities/ring_buffer/: ring_buffer.c
  group platforms\ARM_CM4
    ../../../platforms/ARM_CM4/: crt0_KEIL.c
  group platforms\STM32F4xx
    ../../../platforms/STM32F4xx/: platform_init.c platform_vector_table.c platform_unhandled_isr.c platform_isr.c
  group platforms\STM32F4xx\peripherals
    ../../../platforms/STM32F4xx/peripherals/: system_stm32f4xx.c
  group platforms\STM32F4xx\peripherals\libraries\src
    ../../../platforms/STM32F4xx/peripherals/libraries/src/: stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group system\FreeRTOS\ver10.0.1\Source
    ../../../system/FreeRTOS/ver10.0.1/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../system/FreeRTOS/ver10.0.1/Source/portable/MemMang/: heap_4.c
    ../../../system/FreeRTOS/ver10.0.1/Source/portable/RVDS/ARM_CM4F/: port.c
